# Keil uVision project ch554_txm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ch554_txm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Debug.C Main.C CompatibilityHID.C CH552.h nec.c Main.c Timer.c Timer.h PWM.c PWM_Main.c PWM.h
